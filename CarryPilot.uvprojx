# Keil uVision project CarryPilot.uvprojx, settings and files
target CarryPilot (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CarryPilot +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_BLIZZARD_RB1 __USE_ANSI_EXAMPLE_RAND
  c misc: --wchar32
  c include: .\Libraries\inc;.\WP_Ctrl;.\WP_Src;.\User;.\Libraries\utils;.\Libraries\driverlib
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Library
    ./Libraries/driverlib/: adc.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c lcd.c mpu.c pwm.c qei.c shamd5.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
  group User
    ./User/: Headfile.h main.c startup_rvmdk.S
    ./Libraries/utils/: uartstdio.c
  group CP_Src
    ./WP_Src/: Calibration.c Bling.c Filter.c GPS.c IST8310.c Key.c mpu6050.c myiic.c OLED.c OpticalFlow_LC306.c PID.c PPM.c RC.c Ringbuf.c Schedule.c SINS.c SPL06.c Time.c Time_Cnt.c US_100.c SYSTEM.c Usart.c WP_ADC.c wp_flash.c WP_Math.c WP_PWM.c Soft_I2C.c ssd1306.c RDroneSudio.c ICM20689.c QMC5883.c tfmini.c tfmini.h
  group CP_Ctrl
    ./WP_Ctrl/: CalibrationRoutines.c control_althold.c control_land.c control_poshold.c WP_Ctrl.c Earth_Declination.c copyright.o NamelessCorun_OpticalFlow.c NamelessCotrun_SDK.c OpticalFlow_Control.c Sensor.c Compass.c Temperature_Ctrl.c
